Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-01-18T14:39:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 18 14:39:38 2024 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\8f7cd2e0-03ab-4ff1-affa-af7c0cebbbaf\9029e3dd-1cf2-473d-b5a1-c34b99f0a87a\ifc * Database version: 5507 * Database creation date: Thu Jan 18 14:39:37 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 18 14:39:37 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 18 14:39:37 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 2838FN Oras Optima, 2838FN(2023):2838FN Oras Optima:347338
In: Level 1
Type - PredefinedType: FAUCET; Material: Chrome
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 236.5 mm; NominalHeight: 357.1 mm; NominalWidth: 53.5 mm
Type - General - Author: BIMStone; BIMObjectName: 2838FN(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Kitchen faucet with high spout; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 16/01/2024
Type - Green Building Properties - EAN Number: 6414150102417; ETIM Class Number: EC011431 Kitchen mixing tap; Sales Package dimensions (LxWxH): 580 x 290 x 75; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/2838FN; 3D View: https://static.oras.com/AR/2838FN; Catalog Drawing URL: http://static.oras.com/catdrw/2838FN; Dimension Drawing URL: http://static.oras.com/dimdrw/2838FN; FDV Document URL: http://www.oras.com/datasheet/2838FN/en/fdv; Group: Sales item; Installation and Maintenance Guide URL: http://static.oras.com/manual/2838FN; Interactive AR View URL: https://static.oras.com/AR/2838FN; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/2838FN; Model: 2838FN Oras Optima; Name_en: 2838FN Oras Optima; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2838FN; Product Family: null Single-lever; Product Image URL: http://static.oras.com/image/2838FN; Product URL: http://static.oras.com/2838FN; Spare-Part Information URL: http://static.oras.com/sp/2838FN; Technical DataSheet URL: http://www.oras.com/datasheet/2838FN/en; Type Name: 2838FN Oras Optima; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Aerator: Standard aerator; Connection: Flexible inlet pipes; Connection Size: G3/8; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Spout Projection: 225 mm; Spout Swivel Range: 120°; Spout Type: Swivel spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2838FN(2023); Features: Kitchen faucet; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2838FN; Name: 2838FN Oras Optima; ReplacementCost: n/a; Shape: Sculptured; Size: 54x261.5x338 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.12069 m2; Volume: 0.00501501 m3
Identity Data - Mark: 22
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2838FN(2023): 2838FN Oras Optima; Family and Type: 2838FN(2023): 2838FN Oras Optima; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2838FN(2023): 2838FN Oras Optima; Type Id: 2838FN(2023): 2838FN Oras Optima; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
